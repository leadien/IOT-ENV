# Keil uVision project AP.uvproj, settings and files
target flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RunInFlash +hex
  AfterMake: D:\work\IOT-ENV\Project\CopyAPHex.bat
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: RUN_IN_INTER_MEM, STM32F10X_HD, USE_STM3210E_EVAL,WERS_AP_DEVICE
  c include: ..\inc;..\FWLib\inc;..\Board;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\Ports;..\uCOS-II\uC-LIB;..\APP;..\RF;..\RF\mrfi;..\lwip\include;..\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x6c100000 size 0x10000
  group APP
    ../APP/: main.c stm32f10x_it.c dtimer.c sock_app.c flash.c uart.c
  group Board
    ../Board/: core_cm3.c stm32_eval.c system_stm32f10x.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RF
    ../RF/: spi_cc1100.c rf_wd.c rf_mem.c
    ../RF/mrfi/: mrfi.c
    ../RF/bsp/: bsp.c
    ../RF/nwk/: nwk.c nwk_api.c nwk_frame.c nwk_globals.c nwk_QMgmt.c
    ../RF/nwkapp/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_security.c
    ../RF/app/: WERS.c
  group uCOS-II/Ports
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uCOS-II/CPU
    ../uCOS-II/uC-CPU/: cpu_a.asm
  group uCOS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group lwip_netif
    ../lwip/netif/: etharp.c loopif.c dm9kif.c
  group lwip_api
    ../lwip/api/: api_lib.c api_msg.c err.c sockets.c tcpip.c
  group lwip_core
    ../lwip/core/: dhcp.c inet.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwip_core_ipv4
    ../lwip/core/ipv4/: icmp.c ip.c ip_addr.c ip_frag.c
  group lwip_arch
    ../lwip/arch/: sys_arch.c
target ram (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: RunInRam
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STM3210E_EVAL,MRFI_CC1100,WERS_AP_DEVICE
  c include: ..\inc;..\FWLib\inc;..\Board;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\Ports;..\uCOS-II\uC-LIB;..\APP;..\RF;..\RF\mrfi;..\uIP-1.0\uip;..\Board\uIP_DM9000;..\lwip\include;..\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x7000
  memory RVCT9: RAM 0x20007000 size 0x9000
target extsram (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: RunInExtRam
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STM3210E_EVAL,WERS_AP_DEVICE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000200 size 0xfe00
  memory RVCT10: RAM 0x68080000 size 0x80000
target nor (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: RunInExtNor +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL,WERS_AP_DEVICE
  c include: ..\;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Board;..\..\..\Board\STM32F103ZE-EK
  library: MicroLIB
  memory RVCT4: ROM 0x64000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x10000
